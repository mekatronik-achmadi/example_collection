********************************************************************************
*           Electronic circuit simulation file generated by gSpiceUI           *
*                         Version 1.1.00 (2015-04-29)                          *
********************************************************************************

* /home/achmadi/development/Projects/my_example/circuit/kicad_spice_demo/lm358/opamp.cir

* Include Directives
.include lm358.mod

* Component Definitions
R1 Net-_R1-Pad1_ v_in 1k
R2 Net-_R2-Pad1_ Net-_R1-Pad1_ 5k
R3 Net-_R3-Pad1_ v_off 1k
R4 Net-_R4-Pad1_ Net-_R2-Pad1_ 1k
R5 0 Net-_R4-Pad1_ 1k
R6 v_out Net-_R3-Pad1_ 1k
V1 v_in 0 sin(0 1m 500)
V2 v_p 0 3.3
V3 v_m 0 -3.3
V4 v_off 0 60mV
XU1 ? Net-_R1-Pad1_ 0 v_m ? Net-_R2-Pad1_ v_p ? LM358
XU2 v_m Net-_R3-Pad1_ Net-_R4-Pad1_ ? ? v_out v_p ? LM358

* NG-Spice Simulation Commands
.OPTIONS NOPAGE WIDTH=88
.PRINT TRAN V(v_off) V(v_out) V(v_in)
.TRAN 10.00m 100.00m 0.00m

.END
